# Keil uVision project antenna_keil.uvprojx, settings and files
target Debug (6090000::V6.9::.\ARMCLANG)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Example
  c flags: Optim=7 v6Lang=5 v6LangP=6 wLevel=3
  c define: HSE_VALUE=8000000 DATA_IN_ExtSDRAM STM32F429I_DISCOVERY
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source
    ./: main.c
    ./: gui.c Factory.cpp Factory.h UserInterface.cpp UserInterface.h
  group Config
    ./xf/config/: xf-config.h
    ./: xf-port-config.h
  group XF_Core
    ./xf/core/: behavior.cpp customevent.cpp initialevent.cpp nulltransition.cpp timeout.cpp
  group XF_Include
    ./xf/include/xf/: behavior.h customevent.h event.h eventstatus.h initialevent.h nulltransition.h timeout.h xf.h
  group XF_Interface
    ./xf/include/xf/interface/: dispatcher.h mutex.h reactive.h resourcefactory.h thread.h timeoutmanager.h eventqueue.h
  group XF_Port
    ./xf/port/: port-functions.h
    ./xf/port/stm32-rtos2-keil/: mutex.cpp mutex.h resourcefactory.cpp resourcefactory.h thread.cpp thread.h timeoutmanager.cpp timeoutmanager.h xf.cpp eventqueue.cpp eventqueue.h
    ./xf/port/default/: dispatcher-active.cpp dispatcher-active.h
  group Platform
    ./platform/f7-disco-gcc/mcu/: mcu.h
    ./platform/f7-disco-gcc/mcu/critical/: critical.h critical.cpp
target Release (6090000::V6.9::.\ARMCLANG)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: as above
  output: Example
  c flags: Optim=7 v6Lang=5 v6LangP=6 wLevel=3
  c define: HSE_VALUE=8000000 DATA_IN_ExtSDRAM STM32F429I_DISCOVERY
  c include: ..\Antenna_Keil;.\xf\;.\xf\core;.\xf\config;.\xf\include;.\xf\port;.\platform\f7-disco-gcc\mcu;.\platform\f7-disco-gcc;.\xf\port\stm32-rtos2-keil
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 5.2.0, CMSIS:DSP 1.6.0, CMSIS:RTOS:Keil RTX5 5.5.0, CMSIS:RTOS2:Keil RTX5 5.5.0, Board Support:Buttons 1.0.0, Board Support:Touchscreen 1.0.0, Board Support:emWin LCD 1.0.0, CMSIS Driver:I2C 2.8, CMSIS Driver:SPI 2.11, Device:STM32Cube Framework:Classic 1.7.4, Device:STM32Cube HAL:Common 1.7.4, Device:STM32Cube HAL:Cortex 1.7.4, Device:STM32Cube HAL:DMA 1.7.4, Device:STM32Cube HAL:DMA2D 1.7.4, Device:STM32Cube HAL:GPIO 1.7.4, Device:STM32Cube HAL:I2C 1.7.4, Device:STM32Cube HAL:LTDC 1.7.4, Device:STM32Cube HAL:PWR 1.7.4, Device:STM32Cube HAL:RCC 1.7.4, Device:STM32Cube HAL:SPI 1.7.4, Device:STM32Cube HAL:TIM 1.7.4, Device:Startup 2.6.2, Graphics Display:STM32F429I-Discovery 1.0.2, Graphics:CORE 5.46.5
